options:
  parameters:
    author: Alex
    generate_options: qt_gui
    id: XN297_recv
    output_language: python
    title: XN297 NRF24 recv for HackRF
  states: {}

blocks:
- name: LPF_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1,1,1
    start: 10e3
    step: 10e3
    stop: samp_rate/2
    value: 1e6
  states: {}
- name: data_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    start: 2400e6
    step: 100e3
    stop: 2600e6
    value: 2402e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    start: '0'
    step: '1'
    stop: '71'
    value: '9'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: squelch_th
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    start: '-100'
    step: '1'
    stop: '30'
    value: '-15'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: squelch_th
    type: complex
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '011100010000111101010101'
    tagname: preamble_end
    threshold: '0'
    type: byte
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: int(samp_rate/data_rate)
    sensitivity: '1.0'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: LPF_freq
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: LPF_freq/4
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,2,1,1
    size: '1024'
    tr_level: '0.7'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: squelch_sob
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: 1024*8
    gui_hint: 3,0,1,1
    tr_level: '-50'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    entags: 'False'
    gui_hint: 1,0,1,2
    size: 1024*8*8
    srate: samp_rate
    tr_level: '0.7'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: squelch_sob
    type: complex
    ylabel: Signal
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,0,1,3
    marker1: '0'
    size: 1024*8
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: preamble_end
    type: float
    ylabel: Bit stream
    ymax: '2'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
    vga: rx_gain
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:5555
    timeout: '100'
    type: byte
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', digital_gfsk_demod_0, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_const_sink_x_0, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_char_to_float_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', zeromq_pub_sink_0, '0']
- [digital_gfsk_demod_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [low_pass_filter_0, '0', analog_pwr_squelch_xx_0, '0']
- [soapy_hackrf_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
